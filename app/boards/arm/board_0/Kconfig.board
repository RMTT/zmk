## app/boards/arm/board_0/board_0_defconfig
```kconfig
CONFIG_SOC_SERIES_NRF52X=y
CONFIG_SOC_NRF52832_QFAA=y
CONFIG_BOARD_BOARD_0=y

CONFIG_NFCT_PINS_AS_GPIOS=y
CONFIG_GPIO=y
```
